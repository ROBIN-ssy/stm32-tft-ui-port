# Keil uVision project LCD.uvprojx, settings and files
target OLED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\tick;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\KK_OLED\include;..\HARDWARE\KK_OLED\graphics;..\HARDWARE\KK_OLED\driver;..\HARDWARE\KK_UI\include;..\HARDWARE\KK_UI\src;..\HARDWARE\KK_APP\include;..\FWLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
  group KK_OLED
    ../HARDWARE/KK_OLED/graphics/: kk_oled.c kk_oled_draw.c kk_oled_font.c kk_oled_bitmap.c
    ../HARDWARE/KK_OLED/driver/: kk_oled_driver.c
  group KK_UI
    ../HARDWARE/KK_UI/src/: kk_ui.c kk_ui_anim.c kk_ui_draw.c kk_ui_home.c kk_ui_menu.c kk_ui_nav.c kk_ui_page.c kk_ui_dialog.c
  group KK_APP
    ../HARDWARE/KK_APP/src/: kk_ui_app.c kk_ui_fonts.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/tick/: tick.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_tim.c
